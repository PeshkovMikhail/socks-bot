Commit message: gazebo simulation in progress

File: src/socks_bot/description/out1.urdf (robot description, URDF)
Before this commit: robot socks_bot, 4 links, 3 joints
Joints:
- joint wheel_left_joint: axis 0 0 1 -> 1 0 0
- joint wheel_right_joint: axis 0 0 1 -> 1 0 0
